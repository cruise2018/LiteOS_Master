# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,LOS_KERNEL_DEBUG_OUT,STM32F411xE,USE_BOOTLOADER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m3;..\..\..\stm32_driver_hal\STM32F4xx_HAL_Driver\Inc;..\..\..\stm32_driver_hal\STM32F4xx_HAL_Driver\Inc\Legacy;..\Hardware\Inc;..\..\..\comnew\osport;..\..\..\comnew\at;..\..\..\comnew\shell;..\..\..\comnew\device;..\..\..\components\fs\include;..\..\..\components\fota\ota;..\..\..\components\fota\utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F411RE-LiteOS.sct
  link misc: --keep *.o(oshell)
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: main.c sys_init.c usart.c uart_at.c uart_debug.c dwt.c system_stm32f4xx.c board.c bootloader_main.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group stm32_hal_driver
    ../../../stm32_driver_hal/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group osconfig
    ../OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group osport
    ../../../comnew/osport/: iodev.c mem.c mutex.c osport.h ring.c sem.c string.c task.c
  group shell
    ../../../comnew/shell/: shell.h shell_cmd.c shell_main.c shell_test.c
  group at
    ../../../comnew/at/: at.c at.h
  group driver
    ../../../comnew/device/: los_dev.c los_dev.h los_dev_fs.c los_dev_test.c
  group fs
    ../../../components/fs/vfs/: los_vfs.c
  group hardware
    ../Hardware/Src/: hal_flash.c
  group fota
    ../../../components/fota/ota/: ota.c ota_default.c
    ../../../components/fota/utility/: ota_crc.c ota_sha256.c
software components: CMSIS:CORE 5.1.1
